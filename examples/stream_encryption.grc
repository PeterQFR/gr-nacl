options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: packet_len
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/peter/testing/input_decrypted.example
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/peter/testing/input_encrypted.example
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/peter/testing/input.example
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/peter/testing/input.file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: packet_len*20
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: nacl_crypt_tagged_stream_0
  id: nacl_crypt_tagged_stream
  parameters:
    key: '"12345678123456781234567812345678"'
    len_key: '"packet_len"'
    nonce: '"abcdefghabcdefghabcdefgh"'
    rotate_nonce: 'False'
  states: {}
- name: nacl_crypt_tagged_stream_0_0
  id: nacl_crypt_tagged_stream
  parameters:
    key: '"12345678123456781234567812345678"'
    len_key: '"packet_len"'
    nonce: '"abcdefghabcdefghabcdefgh"'
    rotate_nonce: 'False'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', nacl_crypt_tagged_stream_0, '0']
- [nacl_crypt_tagged_stream_0, '0', blocks_file_sink_0_0, '0']
- [nacl_crypt_tagged_stream_0, '0', nacl_crypt_tagged_stream_0_0, '0']
- [nacl_crypt_tagged_stream_0_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
